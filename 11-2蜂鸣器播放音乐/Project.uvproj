# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\ProgramFiles\DevKits\Keil5_MDK\C51\INC\Atmel
  group Source Group 1
    ./: Delay.c Delay.h Timer0.c Timer0.h main.c
