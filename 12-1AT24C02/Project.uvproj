# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c key.h key.c I2C.h I2C.c AT24C02.h AT24C02.c
    D:/Temp/51-main/LCD1602驱动代码/: LCD1602.c LCD1602.h
    ../11-2蜂鸣器播放音乐/: Delay.c Delay.h
